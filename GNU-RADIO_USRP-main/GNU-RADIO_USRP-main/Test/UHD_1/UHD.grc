options:
  parameters:
    author: Daniel G
    generate_options: qt_gui
    id: UHD_1
    output_language: python
    title: receptor
  states: {}

blocks:
- name: Frec_center
  id: variable
  parameters:
    value: '115000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: Frec_center
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: Frec_center
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: Frec_center
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
